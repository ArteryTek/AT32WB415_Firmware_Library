# Keil uVision project project_l1.uvprojx, settings and files
target project_l1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32WB415CCU7-7 ArteryTek
  pack: ArteryTek.AT32WB415_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project_l1 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32WB415CCU7_7,USE_STDPERIPH_DRIVER,AT_START_WB415_V1,ARM_MATH_CM4
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\project\at32wb415_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x17000
  scatter file: .\end_user_code.sct
  group user
    ../src/: at32wb415_clock.c at32wb415_int.c arm_fir_data.c math_helper.c main.c
  group bsp
    ../../../../project/at32wb415_board/: at32wb415_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32wb415_crm.c at32wb415_usart.c at32wb415_flash.c at32wb415_gpio.c at32wb415_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32wb415.s
  group fir_filter
    ./: fir_filter_symbol.txt
  group readme
    ../: readme.txt
