# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32WB415CCU7-7_v2 ArteryTek -AT32WB415CCU7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32WB415CCU7_7; USE_STDPERIPH_DRIVER; AT_START_WB415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32wb415_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f403a_app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32WB415xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32wb415_board/: at32wb415_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32wb415.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
  group firmware
    ../../../../../libraries/drivers/src/: at32wb415_crm.c at32wb415_flash.c at32wb415_gpio.c at32wb415_misc.c at32wb415_tmr.c at32wb415_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32wb415_clock.c at32wb415_int.c iap.c main.c tmr.c usart.c
