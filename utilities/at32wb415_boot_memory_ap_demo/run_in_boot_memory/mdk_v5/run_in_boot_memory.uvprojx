# Keil uVision project run_in_boot_memory.uvprojx, settings and files
target run_in_boot_memory (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32WB415CCU7-7 ArteryTek
  pack: ArteryTek.AT32WB415_DFP.2.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: run_in_boot_memory +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32WB415CCU7_7,USE_STDPERIPH_DRIVER,AT_START_WB415_V1
  c include: ..\..\..\..\project\at32wb415_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\libraries\cmsis\cm4\core_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x1fffac00 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c run_in_boot_memory.c at32wb415_clock.c at32wb415_int.c
  group bsp
    ../../../../project/at32wb415_board/: at32wb415_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32wb415_gpio.c at32wb415_misc.c at32wb415_usart.c at32wb415_crm.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32wb415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
  group readme
    ../: readme.txt
