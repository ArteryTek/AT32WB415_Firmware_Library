# Keil uVision project cmsis_dsp.uvprojx, settings and files
target cmsis_dsp (6140000::V6.14::ARMCLANG)
  device: -AT32WB415CCU7-7 ArteryTek
  pack: ArteryTek.AT32WB415_DFP.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: cmsis_dsp +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32WB415CCU7_7,USE_STDPERIPH_DRIVER,AT_START_WB415_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32wb415_board;..\..\..\..\..\..\libraries\cmsis\dsp\Include;..\..\..\..\..\..\libraries\cmsis\dsp\PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32wb415_clock.c at32wb415_int.c main.c
  group bsp
    ../../../../../at32wb415_board/: at32wb415_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32wb415_gpio.c at32wb415_crm.c at32wb415_usart.c at32wb415_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32wb415.s
  group cmsis_dsp
    ../../../../../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../../../../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
  group readme
    ../: readme.txt
