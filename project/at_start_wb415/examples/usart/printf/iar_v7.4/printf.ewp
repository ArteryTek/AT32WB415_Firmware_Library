# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: AT32WB415CCU7-7_v2 ArteryTek -AT32WB415CCU7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32WB415CCU7_7; USE_STDPERIPH_DRIVER; AT_START_WB415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32wb415_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../at32wb415_board/: at32wb415_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32wb415.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32wb415_crm.c at32wb415_gpio.c at32wb415_misc.c at32wb415_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32wb415_int.c at32wb415_clock.c main.c
