# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32WB415CCU7-7_v2 ArteryTek -AT32WB415CCU7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32WB415CCU7_7; USE_STDPERIPH_DRIVER; AT_START_WB415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32wb415_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32wb415_board/: at32wb415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32wb415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
  group firmware
    ../../../../libraries/drivers/src/: at32wb415_adc.c at32wb415_can.c at32wb415_cmp.c at32wb415_crc.c at32wb415_crm.c at32wb415_debug.c at32wb415_dma.c at32wb415_ertc.c at32wb415_exint.c at32wb415_flash.c at32wb415_gpio.c at32wb415_i2c.c at32wb415_misc.c at32wb415_pwc.c at32wb415_spi.c at32wb415_tmr.c at32wb415_usart.c at32wb415_usb.c at32wb415_wdt.c at32wb415_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32wb415_clock.c at32wb415_int.c main.c
